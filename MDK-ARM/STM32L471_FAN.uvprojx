# Keil uVision project STM32L471_FAN.uvprojx, settings and files
target STM32L471_FAN (6160000::V6.16::ARMCLANG)
  device: STM32L471VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32L471_FAN +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L471xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../.cmsis/include;../MDK-ARM/RTE/_STM32L471_FAN;../USER/APP;../USER/BSP;../USER/GUI;../USER/TASK;../USER/Middle/FreeRTOS/Source/include;../USER/Middle/FreeRTOS/Source/portable/GCC/ARM_CM4F;../USER/Middle/Transfer;../USER/Middle/EmbeddedGUI/src;../USER/Middle/EmbeddedGUI/src/config;../USER/Middle/EmbeddedGUI/porting/stm32l471_fan;../USER/Middle/EmbeddedGUI/driver/bus;../USER/Middle/EmbeddedGUI/driver/lcd;../USER/Middle/EmbeddedGUI/third_party/plutosvg/source;../USER/Middle/EmbeddedGUI/third_party/plutovg/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l471xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dac.c dma.c i2c.c lptim.c quadspi.c rtc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_lptim.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group USER/TASK
    ../USER/TASK/: freertos_hooks.c user_HardwareInitTask.c user_KeyTask.c user_TasksInit.c user_KeyManllegeTask.c user_LEDTask.c user_FanTask.c user_EGUITask.c user_TransmitTask.c user_AppDataTask.c user_WeatherSyncTask.c
  group USER/APP
    ../USER/APP/: sensors_app.c eeprom_app.c settings_app.c data_app.c weather_app.c home_scene_res.c psram_app.c systemMonitor_app.c led_app.c fan_app.c pwm_fan_control.c fan_anim_res.c poetry_app.c heiti_font_drv.c
  group USER/BSP
    ../USER/BSP/: bq24295_reg.c defin_common.c ee24.c ina226_reg.c key.c lcd.c lcd_init.c lis3dh_reg.c log.c max17048_reg.c multi_led.c qspi_psram.c rgb_led.c sht40_reg.c spi_flash.c systemMonitor.c
  group USER/Middle/Transfer
    ../USER/Middle/Transfer/: i2c_bus.c lfs.c lfs_port.c lfs_util.c lwrb.c uart_dma.c
  group USER/Middle/FreeRTOS
    ../USER/Middle/FreeRTOS/Source/: list.c queue.c tasks.c timers.c event_groups.c
    ../USER/Middle/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../USER/Middle/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group USER/GUI
    ../USER/GUI/: ui.c page_manager.c ui_poetry_popup.c ui_heiti_font.c
    ../USER/GUI/screens/: ui_StartPage.c ui_HomePage.c ui_FanPage.c ui_WeatherPage.c ui_SettingPage.c
  group USER/Middle/EmbeddedGUI
    ../USER/Middle/EmbeddedGUI/src/anim/: egui_animation.c egui_animation_alpha.c egui_animation_color.c egui_animation_resize.c egui_animation_scale_size.c egui_animation_set.c egui_animation_timeline.c egui_animation_translate.c egui_animation_value.c egui_interpolator.c egui_interpolator_accelerate.c egui_interpolator_accelerate_decelerate.c egui_interpolator_anticipate.c egui_interpolator_anticipate_overshoot.c egui_interpolator_bounce.c egui_interpolator_cycle.c egui_interpolator_decelerate.c egui_interpolator_linear.c egui_interpolator_overshoot.c egui_view_fade.c
    ../USER/Middle/EmbeddedGUI/src/app/: egui_activity.c egui_dialog.c egui_msgbox.c egui_page_base.c egui_toast.c egui_toast_std.c
    ../USER/Middle/EmbeddedGUI/src/background/: egui_background.c egui_background_color.c egui_background_gradient.c egui_background_image.c
    ../USER/Middle/EmbeddedGUI/src/canvas/: egui_canvas.c egui_canvas_bezier.c egui_canvas_circle_hq.c egui_canvas_compact.c egui_canvas_ellipse.c egui_canvas_gradient.c egui_canvas_line.c egui_canvas_line_hq.c egui_canvas_polygon.c egui_canvas_transform.c egui_canvas_triangle.c
    ../USER/Middle/EmbeddedGUI/src/core/: egui_api.c egui_common.c egui_core.c egui_core_activity.c egui_core_animation.c egui_core_debug.c egui_core_dialog.c egui_core_dirty.c egui_core_key.c egui_core_pfb.c egui_core_toast.c egui_core_touch.c egui_display_driver.c egui_encoder_driver.c egui_event.c egui_focus.c egui_focus_group.c egui_input.c egui_key_event.c egui_motion_event.c egui_pfb_manager.c egui_platform.c egui_region.c egui_rotation.c egui_scroller.c egui_subject.c egui_timer.c egui_touch_driver.c egui_trig_lut.c egui_velocity_tracker.c
    ../USER/Middle/EmbeddedGUI/src/font/: egui_font.c egui_font_lattice.c egui_font_std.c egui_font_ttf.c
    ../USER/Middle/EmbeddedGUI/src/image/: egui_image.c egui_image_decode_utils.c egui_image_file.c egui_image_qoi.c egui_image_rle.c egui_image_std.c egui_image_svg.c
    ../USER/Middle/EmbeddedGUI/src/mask/: egui_mask.c egui_mask_circle.c egui_mask_gradient.c egui_mask_image.c egui_mask_round_rectangle.c
    ../USER/Middle/EmbeddedGUI/src/resource/: egui_i18n.c egui_res_circle_info.c egui_res_font_material_symbols_common_16_4.c egui_res_font_material_symbols_common_20_4.c egui_res_font_material_symbols_common_24_4.c egui_res_font_montserrat_10_4.c egui_res_font_montserrat_12_4.c egui_res_font_montserrat_14_4.c egui_res_font_montserrat_16_4.c egui_res_font_montserrat_18_4.c egui_res_font_montserrat_20_4.c egui_res_font_montserrat_22_4.c egui_res_font_montserrat_24_4.c egui_res_font_montserrat_26_4.c egui_res_font_montserrat_28_4.c egui_res_font_montserrat_30_4.c egui_res_font_montserrat_32_4.c egui_res_font_montserrat_34_4.c egui_res_font_montserrat_36_4.c egui_res_font_montserrat_38_4.c egui_res_font_montserrat_40_4.c egui_res_font_montserrat_42_4.c egui_res_font_montserrat_44_4.c egui_res_font_montserrat_46_4.c egui_res_font_montserrat_48_4.c egui_res_font_montserrat_8_4.c
    ../USER/Middle/EmbeddedGUI/src/shadow/: egui_shadow.c
    ../USER/Middle/EmbeddedGUI/src/style/: egui_style.c egui_style_transition.c egui_theme.c egui_theme_dark.c egui_theme_light.c
    ../USER/Middle/EmbeddedGUI/src/test/: egui_diag.c egui_test.c
    ../USER/Middle/EmbeddedGUI/src/utils/: egui_fixmath.c egui_sprintf.c egui_utils.c
    ../USER/Middle/EmbeddedGUI/src/utils/simple_ringbuffer/: simple_data_ringbuffer.c simple_ringbuffer.c
    ../USER/Middle/EmbeddedGUI/src/widget/: egui_property.c egui_view.c egui_view_activity_ring.c egui_view_analog_clock.c egui_view_animated_image.c egui_view_arc_slider.c egui_view_autocomplete.c egui_view_button.c egui_view_button_matrix.c egui_view_canvas_panner.c egui_view_canvas_viewport.c egui_view_card.c egui_view_chart_axis.c egui_view_chart_bar.c egui_view_chart_common.c egui_view_chart_line.c egui_view_chart_pie.c egui_view_chart_scatter.c egui_view_checkbox.c egui_view_chips.c egui_view_circle_dirty.c egui_view_circular_progress_bar.c egui_view_combobox.c egui_view_compass.c egui_view_deferred_image.c egui_view_digital_clock.c egui_view_divider.c egui_view_dynamic_label.c egui_view_flexlayout.c egui_view_gauge.c egui_view_grid_view.c egui_view_gridlayout.c egui_view_group.c egui_view_heart_rate.c egui_view_image.c egui_view_image_button.c egui_view_keyboard.c egui_view_label.c egui_view_led.c egui_view_line.c egui_view_linear_value_helper.c egui_view_linearlayout.c egui_view_list.c egui_view_list_view.c egui_view_lyric_scroller.c egui_view_menu.c egui_view_mini_calendar.c egui_view_mp4.c egui_view_notification_badge.c egui_view_number_picker.c egui_view_page_indicator.c egui_view_pattern_lock.c egui_view_progress_bar.c egui_view_radio_button.c egui_view_ring_text_basic.c egui_view_roller.c egui_view_scale.c egui_view_scroll.c egui_view_segmented_control.c egui_view_slider.c egui_view_spangroup.c egui_view_spinner.c egui_view_stepper.c egui_view_stopwatch.c egui_view_switch.c egui_view_tab_bar.c egui_view_table.c egui_view_textblock.c egui_view_textinput.c egui_view_tileview.c egui_view_toggle_button.c egui_view_viewpage.c egui_view_viewpage_cache.c egui_view_virtual_grid.c egui_view_virtual_list.c egui_view_virtual_page.c egui_view_virtual_section_list.c egui_view_virtual_stage.c egui_view_virtual_strip.c egui_view_virtual_tree.c egui_view_virtual_viewport.c egui_view_window.c
    ../USER/Middle/EmbeddedGUI/porting/stm32l471_fan/: egui_port_stm32l471_fan.c
software components: CMSIS:CORE 5.5.0
